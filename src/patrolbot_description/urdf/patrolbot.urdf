Commit message: 12 实验1 cmakelists文件 构建 修改修改错误 完成实验1

File: src/patrolbot_description/urdf/patrolbot.urdf (robot description, URDF)
Before this commit: robot patrolbot, 8 links, 7 joints
Links:
- link caster_link: geometry collision geometry ; visual sphere radius=0.035
